# Keil uVision project mid_four.uvproj, settings and files
target project (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: TFT_LCD +hex
  c flags: Optim=1
  c include: F:\MINI_STM32程序;.\include
  asm include: F:\MINI_STM32程序
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ./Startup/: cortexm3_macro.s stm32f10x_vector.s
  group app
    ./App/: main.c stm32f10x_it.c key.c com.c RTC_Time.c IOI2C.c delay.c moto-tim.c led.c eeprom.c MPU6050.c fc.c HMC5883.c my_math.c ADC.c wifi_703n.c ppm_Parallel.c
  group lib
    ./Library/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
